# Keil uVision project Thermal_Camera.uvprojx, settings and files
target Thermal_Camera (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Thermal_Camera +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;..\Drivers\BSP\i2c;..\Drivers\BSP\lcd;..\Drivers\BSP\led;..\Drivers\BSP\flash;..\Drivers\BSP\fonts;..\Drivers\BSP\usart;..\Drivers\BSP\sdram;..\Drivers\BSP\camera;../Drivers/CMSIS/Include;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;..\Drivers\BSP\component\ov2640;..\Drivers\BSP\component\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Application/User
    ../Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/BSP/I2C
    ../Drivers/BSP/i2c/: bsp_i2c.c
  group Drivers/BSP/LED
    ../Drivers/BSP/led/: bsp_led.c
  group Drivers/BSP/Memory
    ../Drivers/BSP/sdram/: bsp_sdram.c
    ../Drivers/BSP/flash/: bsp_qspi_flash.c
  group Drivers/BSP/Camera
    ../Drivers/BSP/component/ov2640/: ov2640.c
    ../Drivers/BSP/: stm324x9i_eval_camera.c
  group Drivers/BSP/USART
    ../Drivers/BSP/usart/: bsp_debug_usart.c
  group Drivers/BSP/LCD
    ../Drivers/BSP/lcd/: bsp_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_uart.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_flash.c stm32f7xx_hal_usart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dcmi_ex.c
software components: CMSIS:CORE 4.3.0
